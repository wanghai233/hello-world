# Keil uVision project 国赛plus.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 国赛plus +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\hardware\driver;.\hardware
  group Source Group 1
    ./: STARTUP.A51
  group user
    ./user/: user.c
  group hardware
    ./hardware/: other.c digit.c key.c hard.c clock.c adc.c at24cxx.c ds18b20.c ccpa.c sonic.c uart.c
    ./hardware/driver/: ds1302.c iic.c onewire.c
